# Keil uVision project TestLib.uvproj, settings and files
target Debug (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: TestLib +hex
  c flags: Optim=1
  c define: _DEBUG
  c include: ..\CM3;..\..\KiteOS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10001000 size 0x7000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group User
    ./: Main.c Gpio.c NVIC.c Target.c Uart.c Startup.s Cpu.s
    ../: Sys.c
target Release (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: DriveBoard +hex
  AfterMake: "C:\Program Files\Keil\ARM\BIN40\fromelf.exe" "..\Output\DriveBoard.axf" -c --output ..\Output\DriveBoard.bin --bin
  c flags: Optim=1
  c include: ..\Common;.\
  asm define: EN_CRP
  memory RVCT4: ROM 0x3000 size 0x40000
  memory RVCT9: RAM 0x10001000 size 0x7000
  memory RVCT10: RAM 0x2007c000 size 0x8000
