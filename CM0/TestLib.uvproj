# Keil uVision project TestLib.uvproj, settings and files
target Debug (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: OsTest +hex
  c flags: Optim=1
  c include: ..\..\KiteOS;..\CM0
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000200 size 0x2000
  group User
    ./: main.c Target.c Uart.c Cpu.s startup.s MD5.c
    ../: Sys.c
