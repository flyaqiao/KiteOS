# Keil uVision project KiteLibCM0.uvproj, settings and files
target Debug (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: KiteLibCM0 (library)
  c flags: Optim=1
  c include: ..\..\KiteOS;..\CM0
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000300 size 0x2000
  group Common
    ./: startup.s Cpu.s Target.c Security.c
    ../: Sys.c
target Release (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: as above
  output: KiteLibCM0 (library)
  c flags: Optim=1
  c include: ..\..\KiteOS;..\CM0
  asm define: EN_CRP
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000300 size 0x2000
